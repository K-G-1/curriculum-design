# Keil uVision project Pwm_12.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Pwm_12 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: qudong.c main.c delay.c Read_IO.c display.c ADC08321.c
